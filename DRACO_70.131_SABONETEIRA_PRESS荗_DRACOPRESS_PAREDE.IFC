Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_70.131_SABONETEIRA_PRESSÃO_DRACOPRESS_PAREDE.IFC
Time: 2023-11-28T14:47:13
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: DRACO_70.131_BICA_PRESSÃO_Default
In: Default Storey
Material: ABS

# IfcBuildingElementProxy: DRACO_70.131_CAPA_Default
In: Default Storey
Material: AISI 304

# IfcBuildingElementProxy: DRACO_70.131_FUNDO_Default
In: Default Storey
Material: AISI 304

# IfcBuildingElementProxy: DRACO_70.131_GUIA_FIXAÇÃO_TRASEIRA_Default
In: Default Storey
Material: AISI 304

# IfcBuildingElementProxy: DRACO_70.131_RECIPIENTE_INTERNO_Default
In: Default Storey
Material: PP Copolímero

# IfcBuildingElementProxy: DRACO_70.131_SABÃO_NÍVEL-1_Default
In: Default Storey
Material: Água

# IfcBuildingElementProxy: DRACO_70.131_SABÃO_NÍVEL-2_Default
In: Default Storey
Material: Água

# IfcBuildingElementProxy: DRACO_70.131_SABÃO_NÍVEL-3_Default
In: Default Storey
Material: Água

# IfcBuildingElementProxy: DRACO_70.131_TAMPA_ABASTECIMENTO_Default
In: Default Storey
Material: AISI 304

# IfcBuildingElementProxy: DRACO_70.131_VISOR_Default
In: Default Storey
Material: Acrílico (médio-alto impacto)

# IfcElementAssembly: DRACO_70.131_SABONETEIRA_PRESSÃO_DRACOPRESS_PAREDE
In: Default Storey
PSet_Mass_Property - Mass Measure: 1.11577; Area Measure: 0.342986 m2; Volume Measure: 0.000515197 m3
